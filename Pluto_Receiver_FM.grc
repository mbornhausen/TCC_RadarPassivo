options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    realtime_scheduling: '1'
    title: FM Receiver
  states: {}

blocks:
- name: audio_decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: interpretation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rf_decimation
  id: variable
  parameters:
    value: '5'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: sq_level
  id: variable_qtgui_range
  parameters:
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: tuning
  id: variable_qtgui_chooser
  parameters:
    label: station
    label0: '101.3'
    label1: '93.5'
    label2: '94.1'
    label3: '94.3'
    num_opts: '4'
    option0: '101300000'
    option1: '93500000'
    option2: '94100000'
    option3: '94300000'
    type: real
    value: '101300000'
    widget: radio_buttons
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.050'
    stop: '1'
    value: '0.300'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: audio_decimation
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: int(sample_rate/rf_decimation)
    deviation: deviation
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.300'
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '0x4000'
    filter_source: '''Auto'''
    frequency: tuning
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_fm_demod_cf_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_simple_squelch_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
