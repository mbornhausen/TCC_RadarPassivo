options:
  parameters:
    generate_options: qt_gui
    id: doppler_pluto_rtl_tcc
    output_language: python
    title: doppler_pluto_rtl
  states: {}

blocks:
- name: attenuation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: audio_decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: interpretation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rf_decimation
  id: variable
  parameters:
    value: '5'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '70'
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: sample_rate_RTL
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: sq_level
  id: variable_qtgui_range
  parameters:
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: tone_freq
  id: variable_qtgui_range
  parameters:
    start: '-2e3'
    step: '1'
    stop: 2e3
    value: '500'
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    start: '88'
    step: '.2'
    stop: '108'
    value: '104.3'
  states: {}
- name: tuning
  id: variable_qtgui_chooser
  parameters:
    label: station
    label0: '101.3'
    label1: '93.5'
    label2: '94.1'
    label3: '94.3'
    num_opts: '4'
    option0: '101300000'
    option1: '93500000'
    option2: '94100000'
    option3: '94300000'
    type: real
    value: '101300000'
    widget: radio_buttons
  states: {}
- name: tuning_0
  id: variable_qtgui_chooser
  parameters:
    label: station
    label0: '101.3'
    label1: '93.5'
    label2: '94.1'
    label3: '94.3'
    num_opts: '4'
    option0: '101300000'
    option1: '93500000'
    option2: '94100000'
    option3: '94300000'
    type: real
    value: '101300000'
    widget: radio_buttons
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.050'
    stop: '1'
    value: '0.300'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: audio_decimation
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: int(sample_rate/rf_decimation)
    deviation: deviation
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: sample_rate_RTL/5
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: '32768'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '200'
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.300'
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '32768'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '32768'
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '32768'
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '32768'
    type: float
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import csv
      import time
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Save FFT to CSV',
                  in_sig=[(np.float32, 32768)],
                  out_sig=[]
              )
              self.filename = "fft_magnitude.csv"
              self.start_time = time.time()
              self.header_written = False

          def work(self, input_items, output_items):
              fft_vectors = input_items[0]  # shape: (N, 32768)

              with open(self.filename, 'a', newline='') as f:
                  writer = csv.writer(f)

                  if not self.header_written:
                      # Write header: tempo, mag0, mag1, ..., mag32767
                      header = ['timestamp'] + [f'mag_{i}' for i in range(32768)]
                      writer.writerow(header)
                      self.header_written = True

                  for vector in fft_vectors:
                      timestamp = time.time() - self.start_time
                      row = [timestamp] + vector.tolist()
                      writer.writerow(row)

              return len(input_items[0])
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '32768'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(32768)
  states: {}
- name: iio_pluto_source_0_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '0x4000'
    filter_source: '''Auto'''
    frequency: tuning
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '5'
    gain: '1'
    samp_rate: sample_rate_RTL/5
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    label: Gain
    label1: comparacao_sinais
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '204'
    interp: '192'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: tuning_0
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sample_rate_RTL
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_fm_demod_cf_0, '0']
- [analog_wfm_rcv_0, '0', audio_sink_0_0_1, '0']
- [blocks_complex_to_mag_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_freq_sink_x_3, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', epy_block_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_skiphead_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [iio_pluto_source_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [iio_pluto_source_0_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [rational_resampler_xxx_1, '0', low_pass_filter_0_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
